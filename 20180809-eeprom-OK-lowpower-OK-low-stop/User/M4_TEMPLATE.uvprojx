# Keil uVision project M4_TEMPLATE.uvprojx, settings and files
target GPS (ARM-ADS)
  device: STM32F401CCYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: GPS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F401xx,USE_STDPERIPH_DRIVER,USE_HSE_BYPASS
  c include: ..\User;..\Core;..\Fwlib\inc;..\Assitant\delay;..\Assitant\usart;..\GINavSolution
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x200000
  group Fwlib
    ../Fwlib/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_i2c.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_dma.c stm32f4xx_iwdg.c stm32f4xx_exti.c stm32f4xx_pwr.c
  group User
    ./: CommData.c main.c stm32f4xx_it.c system_stm32f4xx.c hw_config.c 24cxx.c Delay.c spi.c stmflash.c GetNass.c GetGPS.c GetAcc.c GetGyr.c myiic.c GetIMU.c SendGps.c iwdg.c EEPROM.c
  group Core
    ../Core/: startup_stm32f401xx.s ALPU-C-0FF.lib
    ./: EncryptID.c
  group GINavSolution
    ../GINavSolution/: DataProc.c GINavMain.c BasicFunc.c GIFilter.c GlobalVars.c Gnss.c InsAlign.c InsNav.c
